Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T17:05:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 17:05:56 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{60C51029-0193-41AE-8C89-EC3DE443A529}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 17:05:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 17:05:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 17:05:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR182 - HTC 7, Panca DOLOMITI:0PAAR182 - HTC 7:160402
In: 0 - Piano Terra
Type - Material: Acciaio, HTC, OKUME
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca DOLOMITI
Type - Dati identità - BIM Name: DOLOMITI; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR182; Designer: MASSIMO TASCA; Family Name: DOLOMITI; Nome del tipo: 0PAAR182 - HTC 7; URL Eng: https://www.bellitalia.net/en/products/benches/dolomiti/; URL Ita: https://www.bellitalia.net/prodotti/panchine/dolomiti/
Type - Dimensioni - Dimensions: 2000 mm X 770 mm X h 450 mm X H 800 mm
Type - Generale - Descrizione Tecnica Famiglia: Panca modello DOLOMITI con due supporti in HTC e piano seduta e schienale in legno Okume.; Descrizione Tecnica per Codice: PANCA DOLOMITI WS IN HTC 7 - BIANCO LISCIO CASSERO VERNICIATURA ANTI-DEGRADO E SEDUTA IN LEGNO DI OKUME; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: DOLOMITI model bench with two HTC supports and seat and backrest in Okume wood.; Technical Description for Article: DOLOMITI WS BENCH IN HTC 7 - WHITE SMOOTH FORMWORK ANTI-DECAY VARNISH AND OKUME WOOD SEAT
Type - Materiali e finiture - MATERIALE PIASTRE: Acciaio; Materiale Principale: HTC 7; Materiale Secondario: HTC; Legno Okume; MATERIALE SEDUTA: OKUME; MATERIALE SUPPORTO: HTC; Primary Material: HTC 7; Secondary Material: HTC; Okume Wood
Type - Meccanica - Weight ( kg): 197 Kg.
Pset_BuildingElementProxyCommon - Reference: 0PAAR182 - HTC 7
Altro - Famiglia: Panca DOLOMITI: 0PAAR182 - HTC 7; Famiglia e tipo: Panca DOLOMITI: 0PAAR182 - HTC 7; ID tipo: Panca DOLOMITI: 0PAAR182 - HTC 7; Tipo: Panca DOLOMITI: 0PAAR182 - HTC 7
Dimensioni - Area: 2.69987 m2; Volume: 0.11774 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
